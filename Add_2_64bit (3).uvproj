# Keil uVision project Add_2_64bit (3).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Add_2_64bit
  c flags: Optim=1
  group Source Group 1
    ./: add_2_64bit.s
