# Keil uVision project Multiply_and_Accumulate_2Arrays (8).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Multiply_and_Accumulate_2Arrays
  c flags: Optim=1
  group Source Group 1
    ./: Multiply_and_Accumulate_2Arrays.s
