# Keil uVision project Arrange_ascendingdescending_BubbleSort (10).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Arrange_ascendingdescending_BubbleSort
  c flags: Optim=1
  group Source Group 1
    ./: ARRANGE.s
