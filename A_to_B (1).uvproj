# Keil uVision project A_to_B (1).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: A_to_B
  c flags: Optim=1
  group Source Group 1
    ./: A_to_B.s
