# Keil uVision project Add_N_32bit (4).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Add_N_32bit
  c flags: Optim=1
  group Source Group 1
    ./: Add_N_32bit.s
