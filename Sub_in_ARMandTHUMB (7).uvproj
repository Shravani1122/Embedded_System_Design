# Keil uVision project Sub_in_ARMandTHUMB (7).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Sub_in_ARMandTHUMB
  c flags: Optim=1
  group Source Group 1
    ./: Sub_in_ARMandTHUMB.s
