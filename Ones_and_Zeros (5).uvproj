# Keil uVision project Ones_and_Zeros (5).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Ones_and_Zeros
  c flags: Optim=1
  group Source Group 1
    ./: onesandzeros.s
