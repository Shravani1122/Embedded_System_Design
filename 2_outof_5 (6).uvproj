# Keil uVision project 2_outof_5 (6).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: 2_outof_5
  c flags: Optim=1
  group Source Group 1
    ./: 2_outof_5.s
