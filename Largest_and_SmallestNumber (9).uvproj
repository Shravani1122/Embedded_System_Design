# Keil uVision project Largest_and_SmallestNumber (9).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Largest_and_SmallestNumber
  c flags: Optim=1
  group Source Group 1
    ./: largestsmallest.s
